# Keil uVision project Interrupt.uvprojx, settings and files
target N32G031 (6240000::V6.24::ARMCLANG)
  device: N32G031C8 Nationstech
  pack: Nationstech.N32G031_DFP.1.0.6
  cpu: IRAM(0x20000000,0x2000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: Interrupt +hex
  AfterMake: fromelf --bin --output=.\bin\Interrupt.bin .\Objects\Interrupt.axf
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=1
  c define: N32G031, USE_STDPERIPH_DRIVER,LOG_ENABLE=1,SYSCLK_SRC=SYSCLK_USE_HSI,SYSCLK_FREQ=8000000
  c include: ..\inc;..\firmware\CMSIS\core;..\firmware\CMSIS\device;..\firmware\n32g031_std_periph_driver\inc;..\peripherals\sensor;..\peripherals\radio;..\peripherals\radio\delay;..\peripherals\radio\llcc68;..\peripherals\common;..\peripherals\bsp;..\peripherals\app;..\peripherals\log;..\peripherals\radio\llcc68_example\llcc68_send;..\peripherals\radio\llcc68_example\llcc68_recive
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  scatter file: .\n32g031.sct
  group STARTUP
    ../firmware/CMSIS/device/startup/: startup_n32g031.s
  group CMSIS
    ../firmware/CMSIS/device/: system_n32g031.c
  group FWLB
    ../firmware/n32g031_std_periph_driver/src/: misc.c n32g031_gpio.c n32g031_rcc.c n32g031_usart.c n32g031_exti.c n32g031_flash.c n32g031_spi.c n32g031_tim.c n32g031_pwr.c n32g031_rtc.c n32g031_adc.c n32g031_lptim.c n32g031_iwdg.c
  group USER
    ../src/: main.c n32g031_it.c
  group DOC
    ../: readme.txt
  group peripherals\app
    ../peripherals/app/: app_cmd.c app_cmd.h app_dev_param.c app_dev_param.h app_lora.c app_lora.h app_lowpower.c app_lowpower.h app_pair.c app_pair.h app_power.c app_power.h app_runtime_state.c app_runtime_state.h app_sensor.c app_sensor.h app_time.c app_time.h
  group peripherals\bsp
    ../peripherals/bsp/: bsp_adc.c bsp_adc.h bsp_gpio.c bsp_gpio.h bsp_lowpower.c bsp_lowpower.h bsp_rtc.c bsp_rtc.h bsp_uart.c bsp_uart.h
  group peripherals\common
    ../peripherals/common/: crc16_modbus.c crc16_modbus.h protocol_util.h storage.c storage.h time_convert.c time_convert.h
  group peripherals\radio
    ../peripherals/: LLCC68N32G031-board.c
    ../peripherals/radio/: llcc68-board.h radio.h
    ../peripherals/radio/llcc68/: llcc68.c llcc68.h project_config.h radio.c
    ../peripherals/radio/delay/: delay.c delay.h
  group peripherals\sensor
    ../peripherals/sensor/: level_uart.c level_uart.h water_cu.c water_cu.h
  group peripherals\log
    ../peripherals/log/: log.c log.h
